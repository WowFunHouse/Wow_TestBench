# Keil uVision project X01_led_pj01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: X01_led_pj01
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led001.c
