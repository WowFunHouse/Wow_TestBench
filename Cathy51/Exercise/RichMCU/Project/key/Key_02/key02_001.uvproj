# Keil uVision project key02_001.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: key02_001 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Header Files
    ./: lib_uty001.h device_scankey.h
  group Utility
    ./: lib_uty001.c
  group Library
    ./: device_scankey.c
  group Application
    ./: key02_001_main.c
