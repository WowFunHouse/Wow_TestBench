# Keil uVision project lcd_pj02.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: lcd_pj01.zzz +hex
  c flags: Optimize=8 SizeSpeed=1
  group Application
    ./: lcd002.c
  group Utility
    ./: lib_uty001.c
  group Lcd Library
    ./: lcd_lib002.c
  group Header Files
    ./: lib_uty001.h hw_rz51v2.h lcd_lib002.h
