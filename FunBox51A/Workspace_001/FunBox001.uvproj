# Keil uVision project FunBox001.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: FunBox001 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Controller
    ./: master_A001.c
  group Common
    ./: support_A01.c
    ../Library/: lib001.c device_led.c device_beeper.c
  group Devices
    ./: sw_A001.c led_A001.c beep_A001.c
